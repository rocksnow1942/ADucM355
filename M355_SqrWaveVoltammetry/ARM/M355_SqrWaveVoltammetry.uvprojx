# Keil uVision project M355_SqrWaveVoltammetry.uvprojx, settings and files
target ADuCM355 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ADuCM355 Analog Devices
  pack: AnalogDevices.ADuCM355_DFP.1.0.3
  cpu: IRAM(0x20000000,0x02000) IRAM2(0x20002000,0x02000) IROM(0x00000000,0x20000) XRAM(0x20004000,0x04000) XRAM2(0x20040000,0x08000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: M355_SqrWaveVoltammetry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=1 wLevel=2
  c define: CHIPSEL_M355
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x20004000 size 0x4000
  memory RVCT7: RAM 0x20040000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x2000
  group app
    ../: AD5940Main.c main.c SqrWaveVoltammetry.c Temperature.c
    ../cjson/: cJSON.h
software components: CMSIS:CORE 5.4.0, Device:AFE:Operation 0.9.4, Device:Peripheral Libraries:CLOCK 0.9.4, Device:Peripheral Libraries:GPIO 0.9.4, Device:Peripheral Libraries:INT 0.9.4, Device:Peripheral Libraries:RST 0.9.4, Device:Peripheral Libraries:UART 0.9.4, Device:Retarget UART 0.9.4, Device:Startup 0.9.4, Data Exchange:JSON:cJSON 1.7.7
